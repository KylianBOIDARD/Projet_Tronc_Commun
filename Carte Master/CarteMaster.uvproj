# Keil uVision project CarteMaster.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: CarteMaster
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Config_Globale.c FO-M6.c FOM1.c decodage.c encodage.c FO-M2.c FO_M3.c FO-M4.c FO_MS1.c
